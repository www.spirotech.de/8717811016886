Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_BC150FM_INT-EN.ifc
Time: 2025-08-05T18:25:26+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1972525_1
Port_1972525_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC150FM, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC150FM:1972525
In: F00
Type - Material: Color RGB 168-128-048, Color RAL 1003, Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 040-040-040
Type - Other - Category: Pipe Accessories; Air Vent Distance: 100 mm; B: 362.5 mm; Base Flange: 12 mm; Base Flange Radius: 84.15 mm; Chamfer Radius: 64.8 mm; Cone Flange: 21 mm; Cone Flange Radius Bottom: 99 mm; Cone Flange Radius Top: 84.15 mm; Connection Diameter: 150 mm; Connection Nominal Diameter: 150 mm; Connection Outer Diameter: 168.3 mm; Depth Service Space: 324 mm; Distance to Valve: 219 mm; DN: 150 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Flange Body: 19 mm; Flange Body Radius: 142.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 106 mm; h: 540 mm; h1: 560 mm; Height Body Drain: 0 mm; Inner Diameter Ring: 6 mm; Length Body: 505 mm; L Feet: 54.55 mm; LF Radius: 317.5 mm; L Radius: 262.5 mm; OD: 168.3 mm; Offset Bracket: 908.348 mm; Offset Drain: 0 mm; Offset Drain Top: 0 mm; Offset Handle: 299 mm; Offset Rings: 35 mm; Radius e: 16.85 mm; Total Length Drain: 82.55 mm; x: 540 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 324 mm; H: 1100 mm; L: 525 mm; LF: 635 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Magnet -Flange DN150; Article Type: BC150FM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Magnet -Flange DN150; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811016916; Manufacturer: Spirotech; Manufacturer Art. No.: BC150FM; Manufacturer URL: https://www.spirotech.com/8717811016916; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: BC150FM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BC150FM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.03 m3/s; Pressure Stage: 16; Volume: 0.05 m3; Weight: 74 kg
Type - Mechanical - Flow - Pressure Drop: 4900 Pa
Type - Visibility - Bracket Visibility: no; Double Vent Symbol: no; Flange: yes; Second Drain Visibility: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BC150FM; sets with these values: 2
Other - Bottom Clearance Safe: 540 mm; Connector Length: 635 mm; Connector Position: 317.5 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN: BC150FM; Length Service Space: 635 mm; Top Clearance Safe: 50 mm; Type: BC150FM; Type Id: 1972482
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 1.82645 m2; Maximum Size: 150 mm; Minimum Size: 150 mm; Volume: 0.0884095 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 540 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
