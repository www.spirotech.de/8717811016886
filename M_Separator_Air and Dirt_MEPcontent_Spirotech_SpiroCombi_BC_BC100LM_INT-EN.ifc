Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_BC100LM_INT-EN.ifc
Time: 2025-08-05T18:25:31+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1972530_1
Port_1972530_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC100LM, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC100LM:1972530
In: F00
Type - Material: Color RGB 168-128-048, Color RAL 1003, Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 040-040-040
Type - Other - Category: Pipe Accessories; Air Vent Distance: 88 mm; B: 280 mm; Base Flange: 11 mm; Base Flange Radius: 57.15 mm; Chamfer Radius: 43.8 mm; Cone Flange: 20.5 mm; Cone Flange Radius Bottom: 71 mm; Cone Flange Radius Top: 57.15 mm; Connection Diameter: 100 mm; Connection Nominal Diameter: 100 mm; Connection Outer Diameter: 114.3 mm; Depth Service Space: 239.34 mm; Distance to Valve: 185 mm; DN: 100 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Flange Body: 17 mm; Flange Body Radius: 110 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 79 mm; h: 375 mm; h1: 433 mm; Height Body Drain: 0 mm; Inner Diameter Ring: 6 mm; Length Body: 340 mm; L Feet: 56.55 mm; LF Radius: 237.5 mm; L Radius: 185 mm; OD: 114.3 mm; Offset Bracket: 908.348 mm; Offset Drain: 0 mm; Offset Drain Top: 0 mm; Offset Handle: 182 mm; Offset Rings: 8 mm; Radius e: 16.85 mm; Total Length Drain: 82.55 mm; x: 370 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 219 mm; H: 808 mm; L: 370 mm; LF: 475 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Magnet -Weld DN100; Article Type: BC100LM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Magnet -Weld DN100; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811021286; Manufacturer: Spirotech; Manufacturer Art. No.: BC100LM; Manufacturer URL: https://www.spirotech.com/8717811021286; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: BC100LM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BC100LM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.01306 m3/s; Pressure Stage: 0; Volume: 0.017 m3; Weight: 24 kg
Type - Mechanical - Flow - Pressure Drop: 3700 Pa
Type - Visibility - Bracket Visibility: no; Double Vent Symbol: no; Flange: no; Second Drain Visibility: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BC100LM; sets with these values: 2
Other - Bottom Clearance Safe: 370 mm; Connector Length: 370 mm; Connector Position: 185 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN: BC100LM; Length Service Space: 370 mm; Top Clearance Safe: 50 mm; Type: BC100LM; Type Id: 1972492
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.836825 m2; Maximum Size: 100 mm; Minimum Size: 100 mm; Volume: 0.0305966 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 370 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
