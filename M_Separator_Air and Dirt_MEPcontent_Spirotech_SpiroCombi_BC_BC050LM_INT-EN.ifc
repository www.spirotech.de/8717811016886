Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_BC050LM_INT-EN.ifc
Time: 2025-08-05T18:25:38+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_1972536_1
Port_1972536_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC050LM, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC050LM:1972536
In: F00
Type - Material: Color RGB 168-128-048, Color RAL 1003, Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 040-040-040
Type - Other - Category: Pipe Accessories; Air Vent Distance: 100.85 mm; B: 214 mm; Base Flange: 8 mm; Base Flange Radius: 30.15 mm; Chamfer Radius: 31.8 mm; Cone Flange: 19 mm; Cone Flange Radius Bottom: 42 mm; Cone Flange Radius Top: 30.15 mm; Connection Diameter: 50 mm; Connection Nominal Diameter: 50 mm; Connection Outer Diameter: 60.3 mm; Depth Service Space: 239.34 mm; Distance to Valve: 185 mm; DN: 50 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Flange Body: 15 mm; Flange Body Radius: 82.5 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 51.5 mm; h: 286 mm; h1: 361 mm; Height Body Drain: 0 mm; Inner Diameter Ring: 6 mm; Length Body: 251 mm; L Feet: 57.55 mm; LF Radius: 175 mm; L Radius: 130 mm; OD: 60.3 mm; Offset Bracket: 908.348 mm; Offset Drain: 0 mm; Offset Drain Top: 0 mm; Offset Handle: 137 mm; Offset Rings: 25 mm; Radius e: 16.85 mm; Total Length Drain: 81.55 mm; x: 330 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 159 mm; H: 647 mm; L: 260 mm; LF: 350 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Magnet -Weld DN050; Article Type: BC050LM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Magnet -Weld DN050; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; GTIN: 8717811021613; Manufacturer: Spirotech; Manufacturer Art. No.: BC050LM; Manufacturer URL: https://www.spirotech.com/8717811021613; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: BC050LM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BC050LM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 m3/s; Nominal Flow Rate: 0.00347 m3/s; Pressure Stage: 0; Volume: 0.005 m3; Weight: 12 kg
Type - Mechanical - Flow - Pressure Drop: 3000 Pa
Type - Visibility - Bracket Visibility: no; Double Vent Symbol: no; Flange: no; Second Drain Visibility: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BC050LM; sets with these values: 2
Other - Bottom Clearance Safe: 330 mm; Connector Length: 260 mm; Connector Position: 130 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN: BC050LM; Length Service Space: 260 mm; Top Clearance Safe: 50 mm; Type: BC050LM; Type Id: 1972504
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.575051 m2; Maximum Size: 50 mm; Minimum Size: 50 mm; Volume: 0.0126561 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - Flow In: 0 m3/s; System Classification: Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 330 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
