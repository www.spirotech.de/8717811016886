Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 6f0957dd-03e5-4dcf-9efe-4b98d1b06f86, NumberOfSaves: 0]
File name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_BC300LM_INT-EN.ifc
Time: 2025-08-26T15:05:56+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENU) - IFC 23.4.0.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE
Name
Port_50282_1
Port_50282_2

# IfcValve: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC300LM, M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN:BC300LM:50282
In: Level 1
Type - Material: Color RGB 168-128-048, Color RAL 1003, Color RGB 198-000-000, Color RGB 128-128-128, Color RGB 040-040-040
Type - Other - Category: Pipe Accessories; Air Vent Distance: 102 mm; B: 10 mm; Base Flange: 19 mm; Base Flange Radius: 161.9 mm; Chamfer Radius: 122 mm; Cone Flange: 34 mm; Cone Flange Radius Bottom: 180 mm; Cone Flange Radius Top: 161.9 mm; Connection Diameter: 300 mm; Connection Nominal Diameter: 300 mm; Connection Outer Diameter: 323.9 mm; Depth Service Space: 610 mm; Distance to Valve: 321 mm; DN: 0.00328084 mm; Family Name: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Flange Body: 24 mm; Flange Body Radius: 230 mm; Flange Gasket: 3 mm; Flange Gasket Radius: 189 mm; h: 1008 mm; h1: 1062 mm; Height Body Drain: 0 mm; Inner Diameter Ring: 6 mm; Length Body: 973 mm; L Feet: 54.55 mm; LF Radius: 502.5 mm; L Radius: 425 mm; OD: 323.8 mm; Offset Bracket: 908.348 mm; Offset Drain: 0 mm; Offset Drain Top: 0 mm; Offset Handle: 408 mm; Offset Rings: 24 mm; Radius e: 16.85 mm; Total Length Drain: 82.55 mm; x: 900 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - D: 610 mm; H: 2070 mm; L: 850 mm; LF: 1005 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Deaerator & dirt separator - Steel - Magnet -Weld DN300; Article Type: BC300LM; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Deaerator & dirt separator - Steel - Magnet -Weld DN300; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.05; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer Art. No.: BC300LM; Manufacturer URL: https://www.spirotech.com/products/spirocombi/; MEPcontent Class: SEPARATOR_AIR_AND_DIRT; Model: BC300LM; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: BC300LM; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Yellow: Color RAL 1003
Type - Mechanical - Capacity: 0 m3; Flow-through Capacity: 0 dm3/s; Nominal Flow Rate: 112.5 dm3/s; Pressure Stage: 0; Volume: 0.5 m3; Weight: 276 kg
Type - Mechanical - Flow - Pressure Drop: 7800 Pa
Type - Text - Pipe Type Category: M561
Type - Visibility - Bracket Visibility: no; Double Vent Symbol: yes; Flange: no; Second Drain Visibility: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: BC300LM; sets with these values: 2
Other - Bottom Clearance Safe: 900 mm; Connector Length: 850 mm; Connector Position: 425 mm; Family: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN; Family and Type: M_Separator_Air and Dirt_MEPcontent_Spirotech_SpiroCombi_BC_INT-EN: BC300LM; Length Service Space: 850 mm; Top Clearance Safe: 50 mm; Type: BC300LM; Type Id: 50267
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 4.9277 m2; Maximum Size: 300 mm; Minimum Size: 300 mm; Volume: 0.576881 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 1
Mechanical - Flow In: 0 dm3/s; System Classification: Undefined
Phasing - Phase Created: New Construction
Visibility - Bottom Clearance: 900 mm; Counter Flange: no; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
